# Keil uVision project Amur_750.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Amur_750 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\Amur_750;..\..\My_Libraries
  asm include: ..\Amur_750;..\..\My_Libraries
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group User_code
    ./: main.c main.h Config.h
  group Library_code
    ../../My_Libraries/: GPIO_setup.c GPIO_setup.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.0
