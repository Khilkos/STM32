# Keil uVision project Black_Pill_board_2.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Black_Pill_board_2 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c misc: -Wno-invalid-utf8 -Wno-gnu-binary-literal -Wno-invalid-source-encoding
  c include: ..\..\My_Libraries;..\Black_Pill_board_2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User_code
    ./: main.c main.h Board.c
  group Library_code
    ../../My_Libraries/: Core_F411_init.c Delay.c GPIO_setup.c I2C_F411.c 1602_I2C.c HUB_08_F411.c HUB_08_F411.h Font_table.c HUB_75_F411.c HUB_75_F411.h DS3231_F411.c DS18B20_F411.c USART_F411.c DMA_F411.c ADC_F411.c Timer_F411_init.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
