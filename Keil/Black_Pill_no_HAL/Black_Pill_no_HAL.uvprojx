# Keil uVision project Black_Pill_no_HAL.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Black_Pill_no_HAL +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-invalid-source-encoding -Wno-invalid-utf8 -Wno-gnu-binary-literal -Wno-vla -Wno-padded -Wno-newline-eof
  c include: ..\Black_Pill_no_HAL;..\..\My_Libraries
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User_Code
    ./: main.c Board.c Config.c Config.h
  group User_Libs
    ../../My_Libraries/: Delay.c GPIO_setup.c EXTI_F411_init.c ST7920_STM32F4.c Font_table.c RTC_F411.c I2C_F411.c DS18B20_F411.c USART_F411.c DS3231_F411.c One_Wire_F411.c One_Wire_F411.h Core_init.c Core_init.h SPI.c SPI.h ADC.c ADC.h DMA.c DMA.h Timer_F4.c Timer_F4.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
