# Keil uVision project Nucleo_F401RE.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Nucleo_F401RE
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 wLevel=2
  c misc: -Wno-binary-literal -Wno-invalid-utf8 -Wno-invalid-source-encoding -Wno-padded
  c include: ..\Nucleo_F401RE;..\..\My_Libraries
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Board_Lib
    ./: main.c main.h Config.h
  group My_lib
    ../../My_Libraries/: GPIO_setup.c GPIO_setup.h Delay.c Core_init.c Core_init.h SPI.c SPI.h Nokia_5110_LCD.c Nokia_5110_LCD.h Font_table.c ADC.c DMA.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
