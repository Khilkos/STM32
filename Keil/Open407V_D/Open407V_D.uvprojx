# Keil uVision project Open407V_D.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Open407V_D
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-invalid-utf8
  c include: ..\Open407V_D;..\..\My_Libraries
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Program_main
    ./: main.c main.h Config.h Open407_LCD.c Open407_LCD.h
  group User_lib
    ../../My_Libraries/: Core_init.c Delay.c GPIO_setup.c Timer.c FSMC.c Font_table.c Font_table.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
