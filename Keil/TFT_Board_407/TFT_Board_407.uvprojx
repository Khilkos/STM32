# Keil uVision project TFT_Board_407.uvprojx, settings and files
target Target 1 (6230000::V6.23::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TFT_Board_407
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c misc: -Wno-invalid-utf8 -Wno-invalid-source-encoding -Wno-missing-braces -Wno-pointer-sign -Wno-incompatible-pointer-types  -Wno-sign-conversion -Wno-gnu-binary-literal -Wno-implicit-int-conversion
  c include: ..\TFT_Board_407;..\..\My_Libraries
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Program Lib
    ./: main.c Config.h SCADA_init.c SCADA_init.h
  group User_Lib
    ../../My_Libraries/: Core_init.c GPIO_setup.c Delay.c Timer.c FSMC.c SSD1963.c Font_table.c GT911.c I2C.c img.c DMA.c DS18B20.c USART.c One_Wire.c Graph.c Graph.h
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
